# Keil uVision project BirdFlight_V2.0.uvprojx, settings and files
target BirdFlight_V2.0 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4, __FPU_PRESENT=1, __FPU_USED =1, __CC_ARM
  c include: ..\Core;..\Driver;..\Libraries\inc;..\System;..\User;..\uCOS-III\Bsp;..\uCOS-III\Config;..\uCOS-III\Core;..\uCOS-III\CPU;..\uCOS-III\Lib;..\uCOS-III\Port;..\Hardware\SPI;..\Hardware\MPU6500;..\Hardware\IMU_AHRS;..\Hardware\LSM303;..\Hardware\TIMER_AHRS;..\Mymath\MahonyAHRS;..\Libraries\CMSIS\Include;..\Hardware\USART_PC;..\Parameter;..\Control\Inner_control;..\Hardware\TIMER_Timing;..\Mymath\Limits;..\Hardware\Flash;..\Hardware\MCPWM;..\Control\Outer_control;..\Hardware\USART_VISION;..\Mymath\MedianFiler;..\Hardware\TIMER_AHRS_INNER;..\Hardware\ADC_BATTERY;..\Hardware\General_Gpio;..\Hardware\Bluetooth;..\Hardware\USART_BLUETOOTH;..\Mymath\Position;..\Control\Neurons_pid;..\Mymath\Digital_filter;..\Hardware\USART_Ultra;..\Control\Incremental_pid;..\Mymath\UltraCombine;..\Mymath\XYPosition;..\VL53L1X;..\VL53L1X\vl53l1_platform;..\VL53L1X_BSP;..\Hardware\OPTICAL_FLOW;..\Platform;..\LineInspection
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Doc
    ../Doc/: readme.txt
  group Core
    ../Core/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group Libraries
    ../Libraries/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_adc.c
    ../Libraries/inc/: misc.h
    ../Libraries/CMSIS/DSP_Lib/Source/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c
    ../Libraries/CMSIS/DSP_Lib/Source/CommonTables/: arm_common_tables.c
    ../Libraries/CMSIS/DSP_Lib/Source/BasicMathFunctions/: arm_abs_f32.c
  group System
    ../System/: explore_system.c explore_systick.c
  group uC/OS III - BSP
    ../uCOS-III/Bsp/: bsp.c
  group uC/OS III - CPU
    ../uCOS-III/CPU/: cpu_core.c cpu_c.c cpu_a.asm
  group uC/OS III - Lib
    ../uCOS-III/Lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c lib_mem_a.asm
  group uC/OS III - Core
    ../uCOS-III/Core/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/OS III - Port
    ../uCOS-III/Port/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS III - Config
    ../uCOS-III/Config/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group Platform
    ../Platform/: my_platform.c
  group User
    ../User/: stm32f4xx_main.c stm32f4xx_conf.h stm32f4xx_it.c Task.c
  group LineInspection
    ../LineInspection/: LineInspection.c
  group Hardware
    ../Hardware/SPI/: SPI3.c
    ../Hardware/MPU6500/: MPU6500.c
    ../Hardware/IMU_AHRS/: IMU_AHRS.c
    ../Hardware/LSM303/: LSM303D.c
    ../Hardware/USART_PC/: Usart1toPC.c
    ../Hardware/TIMER_Timing/: Timer5_Timing.c
    ../Hardware/Flash/: Flash.c
    ../Hardware/MCPWM/: mcpwm.c
    ../Hardware/USART_VISION/: Usart6toVision.c
    ../Hardware/TIMER_AHRS_INNER/: Timer3_Ahrs_Inner.c
    ../Hardware/ADC_BATTERY/: Adc_Battery.c
    ../Hardware/General_Gpio/: General_Gpio.c
    ../Hardware/USART_BLUETOOTH/: Usart3toBluetooth.c
    ../Hardware/Bluetooth/: Bluetooth.c
    ../Hardware/USART_Ultra/: Usart5toUltra.c
    ../VL53L1X_BSP/: vl53l1x.c vl53lxx.c vl53lxx_i2c.c
    ../Hardware/OPTICAL_FLOW/: maths.c optical_flow.c spi.c
  group Control
    ../Control/Inner_control/: Inner_control.c
    ../Control/Outer_control/: Outer_control.c
    ../Control/Neurons_pid/: Neurons.c
    ../Control/Incremental_pid/: Incremental_pid.c
    ../Mymath/UltraCombine/: UltraCombine.c
    ../Mymath/XYPosition/: XYPositionCombine.c
  group Parameter
    ../Parameter/: DronePara.h Data_PC.c Type_conversion.c Data_deal.c Visiondata_deal.c
  group Mymath
    ../Mymath/MahonyAHRS/: MahonyAHRS.c
    ../Mymath/Limits/: Limits.c
    ../Mymath/MedianFiler/: MedianFiler.c
    ../Mymath/UltraCombine/: InertialFilter.c
    ../Mymath/Position/: Position.c
    ../Mymath/Digital_filter/: digital_filter.c
  group vl53lxx
    ../VL53L1X/: vl53l1_api.c vl53l1_api_calibration.c vl53l1_api_core.c vl53l1_api_debug.c vl53l1_api_preset_modes.c vl53l1_api_strings.c vl53l1_core.c vl53l1_core_support.c vl53l1_error_strings.c vl53l1_register_funcs.c vl53l1_silicon_core.c vl53l1_wait.c
